# Keil uVision project wecd.uvproj, settings and files
target Ai8051U (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: wecd +hex
  link misc: REMOVEUNUSED, NOOVERLAY
  group AiCube
    ./Sources/: main.c port.c clock.c wdt.c iap.c timer.c uart.c i2c.c rtc.c lcm.c Soft_Convert.c
    ./: ina219.c dht11.c esp8266.c uart_rtc.c picture2.h
